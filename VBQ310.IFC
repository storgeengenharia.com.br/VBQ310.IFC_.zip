Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: VBQ310.IFC
Time: 2024-09-09T18:05:30
Written by: SwIFC
Made in: SolidWorks 2023

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Base
In: Default Storey
Material: Aço galvanizado

# IfcBuildingElementProxy: Carcaça
In: Default Storey
Material: Aço galvanizado

# IfcBuildingElementProxy: Fechamento
In: Default Storey
Material: Aço galvanizado

# IfcBuildingElementProxy: Suporte Motor
In: Default Storey
Material: Aço galvanizado
